# Keil uVision project GD32F427.uvprojx, settings and files
target GD32F427 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F427VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F427
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F427
  c include: ..\Core\inc;..\Drivers\CMSIS\GD\GD32F4xx\Include;..\Drivers\GD32F4xx_standard_peripheral\Include;..\Drivers\CMSIS\GD\GD32F4xx\Source\ARM;..\Drivers\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../Core/src/: gd32f4xx_it.c main.c systick.c
  group Application/MDK-ARM
    ../Startup/: startup_gd32f407_427.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Drivers/GD32F4xx_standard_peripheral
    ../Drivers/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
software components: RTOS:kernel 3.1.5
